# Keil uVision project under.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: under +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\dhsjhejdhv
  group Source Group 1
    ./: main.c
    ../../10/source/: STCBSP_V3.6.LIB
